<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\03oos_macpong\03oos_macpong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_openwsn\03oos_openwsn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_sniffer\03oos_sniffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_leds\01bsp_leds.ewp</path>
  </project>
  <batchBuild/>
</workspace>


